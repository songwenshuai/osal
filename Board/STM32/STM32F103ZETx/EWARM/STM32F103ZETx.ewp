# IAR project STM32F103ZETx.ewp, settings and files
configuration STM32F103ZETx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Bsp/Button; ../Bsp/Led; ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/CmBacktrace/Cfg; ../Middlewares/EasyFlash/Cfg; ../Middlewares/Easylogger/Cfg; ../Middlewares/Easylogger/Plugins/flash/Cfg; ../Middlewares/Fal/Cfg; ../Middlewares/Fal/Port; ../Middlewares/Lwmem/Cfg; ../Middlewares/Lwmem/Port; ../Middlewares/OSAL/Cfg; ../Middlewares/SUFD/Cfg; ../Middlewares/SystemView/Config; ../Middlewares/uC-CLK/Cfg; ../Middlewares/uC-LIB/Cfg; ../Middlewares/uC-LIB/Port; ../Middlewares/uC-Shell/Cfg; ../Middlewares/uC-Shell/Terminal/Cfg; ../../../../Middlewares/CmBacktrace/Source; ../../../../Middlewares/DataStructure/Source/Inc; ../../../../Middlewares/EasyFlash/Source; ../../../../Middlewares/EasyLogger/Plugins/flash/Source; ../../../../Middlewares/EasyLogger/Source; ../../../../Middlewares/Fal/Source; ../../../../Middlewares/FlexibleButton/Source; ../../../../Middlewares/FAT-SL/api; ../../../../Middlewares/FAT-SL/config; ../../../../Middlewares/FAT-SL/fat_sl/common; ../../../../Middlewares/FAT-SL/fat_sl/test; ../../../../Middlewares/FAT-SL/psp/include; ../../../../Middlewares/FAT-SL/psp/target/fat_sl; ../../../../Middlewares/FAT-SL/version; ../../../../Middlewares/LittleFs/Cfg; ../../../../Middlewares/LittleFs/Source; ../../../../Middlewares/Lwmem/Source; ../../../../Middlewares/OSAL/Source/Inc; ../../../../Middlewares/Printf/Source; ../../../../Middlewares/SUFD/Source; ../../../../Middlewares/SystemView/SEGGER; ../../../../Middlewares/uC-CLK/Source; ../../../../Middlewares/uC-LIB/Source; ../../../../Middlewares/uC-Shell/Cmd/General; ../../../../Middlewares/uC-Shell/Source; ../../../../Middlewares/uC-Shell/Terminal/Source; ../../../../Sample/App; ../../../../Sample/Hal; ../../../../Sample/Hal/Target
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Middlewares/SystemView/Config; ../../../../Middlewares/SystemView/SEGGER
  OBJCOPY.OOCOutputFile: STM32F103ZETx.hex
  ILINK.IlinkOutputFile: STM32F103ZETx.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Bsp/Button
    ../Bsp/Button/: bsp_pb.c bsp_pb.h
  group Application/Bsp/Led
    ../Bsp/Led/: bsp_led.c bsp_led.h
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Middlewares/CmBacktrace/Cfg
    ../Middlewares/CmBacktrace/Cfg/: cmb_cfg.h
  group Middlewares/CmBacktrace/Source
    ../../../../Middlewares/CmBacktrace/Source/: cm_backtrace.c cm_backtrace.h cmb_def.h
  group Middlewares/CmBacktrace/Source/fault_handler/iar
    ../../../../Middlewares/CmBacktrace/Source/fault_handler/iar/: cmb_fault.S
  group Middlewares/DataStructure/Source/Inc
    ../../../../Middlewares/DataStructure/Source/Inc/: Array.h Fifo.h LinkList.h List.h Queue.h Ring.h
  group Middlewares/DataStructure/Source/Src
    ../../../../Middlewares/DataStructure/Source/Src/: Array.c Fifo.c LinkList.c List.c Queue.c Ring.c
  group Middlewares/EasyFlash/Cfg
    ../Middlewares/EasyFlash/Cfg/: ef_cfg.h
  group Middlewares/EasyFlash/Port
    ../Middlewares/EasyFlash/Port/: ef_fal_port.c
  group Middlewares/EasyFlash/Source
    ../../../../Middlewares/EasyFlash/Source/: easyflash.c easyflash.h ef_env.c ef_iap.c ef_log.c ef_utils.c
  group Middlewares/Easylogger/Cfg
    ../Middlewares/Easylogger/Cfg/: elog_cfg.h
  group Middlewares/Easylogger/Plugins/flash/Cfg
    ../Middlewares/Easylogger/Plugins/flash/Cfg/: elog_flash_cfg.h
  group Middlewares/Easylogger/Plugins/flash/Port
    ../Middlewares/Easylogger/Plugins/flash/Port/: elog_flash_port.c
  group Middlewares/Easylogger/Plugins/flash/Source
    ../../../../Middlewares/EasyLogger/Plugins/flash/Source/: elog_flash.c elog_flash.h
  group Middlewares/Easylogger/Port
    ../Middlewares/Easylogger/Port/: elog_port.c
  group Middlewares/Easylogger/Source
    ../../../../Middlewares/EasyLogger/Source/: elog.c elog.h elog_async.c elog_buf.c elog_utils.c
  group Middlewares/Fal/Cfg
    ../Middlewares/Fal/Cfg/: fal_cfg.h
  group Middlewares/Fal/Port
    ../Middlewares/Fal/Port/: drv_flash.h drv_flash_f1.c fal_flash_sfud_port.c
  group Middlewares/Fal/Source
    ../../../../Middlewares/Fal/Source/: fal.c fal.h fal_def.h fal_flash.c fal_partition.c
  group Middlewares/FAT-SL/api
    ../../../../Middlewares/FAT-SL/api/: api_mdriver.h api_mdriver_ram.h fat_sl.h
  group Middlewares/FAT-SL/config
    ../../../../Middlewares/FAT-SL/config/: config_fat_sl.h config_fat_sl_test.h config_mdriver_ram.h
  group Middlewares/FAT-SL/fat_sl/common
    ../../../../Middlewares/FAT-SL/fat_sl/common/: dir.c dir.h drv.c drv.h f_lock.c f_lock.h fat.c fat.h file.c file.h util.c util.h util_sfn.c util_sfn.h volume.c volume.h
  group Middlewares/FAT-SL/fat_sl/demo
    ../../../../Middlewares/FAT-SL/fat_sl/demo/: File-system-demo.c
  group Middlewares/FAT-SL/fat_sl/test
    ../../../../Middlewares/FAT-SL/fat_sl/test/: test.c test.h
  group Middlewares/FAT-SL/media-drv/ram
    ../../../../Middlewares/FAT-SL/media-drv/ram/: ramdrv_f.c
  group Middlewares/FAT-SL/psp/include
    ../../../../Middlewares/FAT-SL/psp/include/: psp_rtc.h psp_string.h
  group Middlewares/FAT-SL/psp/target/fat_sl
    ../../../../Middlewares/FAT-SL/psp/target/fat_sl/: psp_test.c psp_test.h
  group Middlewares/FAT-SL/psp/target/rtc
    ../../../../Middlewares/FAT-SL/psp/target/rtc/: psp_rtc.c
  group Middlewares/FAT-SL/version
    ../../../../Middlewares/FAT-SL/version/: ver_fat_sl.h ver_mdriver.h ver_mdriver_ram.h ver_psp_fat_sl.h ver_psp_rtc.h ver_psp_string.h
  group Middlewares/FlexibleButton/Port
    ../Middlewares/FlexibleButton/Port/: flexible_button_demo.c
  group Middlewares/FlexibleButton/Source
    ../../../../Middlewares/FlexibleButton/Source/: flexible_button.c flexible_button.h
  group Middlewares/LittleFs/Cfg
    ../../../../Middlewares/LittleFs/Cfg/: lfs_util.h
  group Middlewares/LittleFs/Port
    ../../../../Middlewares/LittleFs/Port/: lfs_util.c
  group Middlewares/LittleFs/Source
    ../../../../Middlewares/LittleFs/Source/: lfs.c lfs.h
  group Middlewares/LittleFs/Test
    ../../../../Middlewares/LittleFs/Test/: littlefs_test.c
  group Middlewares/Lwmem/Cfg
    ../Middlewares/Lwmem/Cfg/: lwmem_config.h lwmem_config_default.h
  group Middlewares/Lwmem/Port
    ../Middlewares/Lwmem/Port/: lwmem_init.c lwmem_sys.h lwmem_sys_nonos.c
  group Middlewares/Lwmem/Source
    ../../../../Middlewares/Lwmem/Source/: lwmem.c lwmem.h
  group Middlewares/OSAL/Cfg
    ../Middlewares/OSAL/Cfg/: OSAL_Config.h
  group Middlewares/OSAL/Port
    ../Middlewares/OSAL/Port/: OSAL_Port.c
  group Middlewares/OSAL/Source/Inc
    ../../../../Middlewares/OSAL/Source/Inc/: OSAL.h OSAL_Cbtimer.h OSAL_Clock.h OSAL_Comdef.h OSAL_Debug.h OSAL_Helper.h OSAL_Message.h OSAL_Mutex.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h
  group Middlewares/OSAL/Source/Src
    ../../../../Middlewares/OSAL/Source/Src/: OSAL.c OSAL_Cbtimer.c OSAL_Clock.c OSAL_Helper.c OSAL_Message.c OSAL_Mutex.c OSAL_PwrMgr.c OSAL_Timers.c
  group Middlewares/Printf/Source
    ../../../../Middlewares/Printf/Source/: printf.c printf.h
  group Middlewares/SUFD/Cfg
    ../Middlewares/SUFD/Cfg/: sfud_cfg.h
  group Middlewares/SUFD/Port
    ../Middlewares/SUFD/Port/: sfud_port.c
  group Middlewares/SUFD/Source
    ../../../../Middlewares/SUFD/Source/: sfud.c sfud.h sfud_def.h sfud_flash_def.h sfud_sfdp.c
  group Middlewares/SystemView/Config
    ../Middlewares/SystemView/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h
  group Middlewares/SystemView/Sample/NoOS/Config/Cortex-M
    ../Middlewares/SystemView/Sample/NoOS/Config/Cortex-M/: SEGGER_SYSVIEW_Config_NoOS.c
  group Middlewares/SystemView/SEGGER
    ../../../../Middlewares/SystemView/SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_GCC.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_Syscalls_SES.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
  group Middlewares/uC-Clk/Cfg
    ../Middlewares/uC-CLK/Cfg/: clk_cfg.h
  group Middlewares/uC-Clk/Source
    ../../../../Middlewares/uC-CLK/Source/: clk.c clk.h
  group Middlewares/uC-LIB/Cfg
    ../Middlewares/uC-LIB/Cfg/: lib_cfg.h
  group Middlewares/uC-LIB/Port
    ../Middlewares/uC-LIB/Port/: cpu.h
  group Middlewares/uC-LIB/Port/IAR
    ../Middlewares/uC-LIB/Port/IAR/: lib_mem_a.asm
  group Middlewares/uC-LIB/Source
    ../../../../Middlewares/uC-LIB/Source/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Middlewares/uC-Shell/Cfg
    ../Middlewares/uC-Shell/Cfg/: shell_cfg.h
  group Middlewares/uC-Shell/Cmd/General
    ../../../../Middlewares/uC-Shell/Cmd/General/: sh_shell.c sh_shell.h
  group Middlewares/uC-Shell/Source
    ../../../../Middlewares/uC-Shell/Source/: shell.c shell.h
  group Middlewares/uC-Shell/Terminal/Cfg
    ../Middlewares/uC-Shell/Terminal/Cfg/: terminal_cfg.h
  group Middlewares/uC-Shell/Terminal/Mode/VT100
    ../../../../Middlewares/uC-Shell/Terminal/Mode/VT100/: terminal_mode.c
  group Middlewares/uC-Shell/Terminal/Serial
    ../Middlewares/uC-Shell/Terminal/Serial/: terminal_serial.c
  group Middlewares/uC-Shell/Terminal/Source
    ../../../../Middlewares/uC-Shell/Terminal/Source/: terminal.c terminal.h
  group Sample
    ../../../../Sample/: OSAL_GenericApp.c
  group Sample/App
    ../../../../Sample/App/: GenericApp.c GenericApp.h
  group Sample/Hal
    ../../../../Sample/Hal/: hal_drivers.c hal_drivers.h
  group Sample/Hal/Target
    ../../../../Sample/Hal/Target/: hal_led.c hal_led.h
