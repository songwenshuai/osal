# IAR project STM32L496VGT6.ewp, settings and files
configuration STM32L496VGT6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496VG ST STM32L496VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L496xx
  ICCARM.CCIncludePath2: ../Bsp/Button; ../Bsp/Led; ../Ports/Armink; ../Ports/Armink/CmBacktrace/inc; ../Ports/Armink/EasyFlash/inc; ../Ports/Armink/Fal/inc; ../Ports/Armink/Easylogger/inc; ../Ports/Armink/Easylogger/plugins/flash; ../Ports/Micrium/uC-CLK/Cfg; ../Ports/Micrium/uC-CRC/Cfg; ../Ports/Micrium/uC-CLK/Cfg; ../Ports/Micrium/uC-LIB/Config; ../Ports/Micrium/uC-LIB/Ports; ../Ports/Micrium/uC-Shell/Cfg; ../Ports/Micrium/uC-Shell/Terminal/Cfg; ../Ports/OSAL/Cfg; ../Ports/Tlsf/Cfg; ../Core/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../../../../Sample/App; ../../../../Sample/Hal; ../../../../Sample/Hal/Target; ../../../../Middlewares/Armink/EasyFlash/easyflash/inc; ../../../../Middlewares/Armink/Fal/inc; ../../../../Middlewares/Armink/EasyLogger/easylogger/inc; ../../../../Middlewares/Armink/EasyLogger/easylogger/plugins/flash; ../../../../Middlewares/Armink/CmBacktrace/cm_backtrace; ../../../../Middlewares/Micrium/uC-LIB; ../../../../Middlewares/Micrium/uC-CRC/Source; ../../../../Middlewares/Micrium/uC-Common/Auth; ../../../../Middlewares/Micrium/uC-Common/Collections; ../../../../Middlewares/Micrium/uC-Common; ../../../../Middlewares/Micrium/uC-CLK/Source; ../../../../Middlewares/Micrium/uC-Shell/Cmd/General; ../../../../Middlewares/Micrium/uC-Shell/Source; ../../../../Middlewares/Micrium/uC-Shell/Terminal/Source; ../../../../Middlewares/OSAL/Source/Inc; ../../../../Middlewares/SEGGER/HardFault/Source; ../../../../Middlewares/SEGGER/SystemView/Config; ../../../../Middlewares/SEGGER/SystemView/SEGGER; ../../../../Module/DataStructure/Inc; ../../../../Module/FlexibleButton; ../../../../Module/Printf; ../../../../Module/Tlsf
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../../Middlewares\SEGGER/SystemView\Config; ../../../../Middlewares\SEGGER/SystemView\SEGGER
  OBJCOPY.OOCOutputFile: STM32L496VGT6.hex
  ILINK.IlinkOutputFile: STM32L496VGT6.out
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Bsp/BUTTON
    ../Bsp/Button/: bsp_pb.c bsp_pb.h flexible_button_demo.c
  group Application/Bsp/LED
    ../Bsp/Led/: bsp_led.c bsp_led.h
  group Application/EWARM
    ./: startup_stm32l496xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Middlewares/Armink/CmBacktrace
    ../../../../Middlewares/Armink/CmBacktrace/cm_backtrace/: cm_backtrace.c
    ../../../../Middlewares/Armink/CmBacktrace/cm_backtrace/fault_handler/iar/: cmb_fault.S
  group Middlewares/Armink/EasyFlash/Port
    ../Ports/Armink/EasyFlash/port/: ef_fal_port.c
  group Middlewares/Armink/EasyFlash/Src
    ../../../../Middlewares/Armink/EasyFlash/easyflash/src/: easyflash.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
  group Middlewares/Armink/Easylogger/Plugins/Flash
    ../../../../Middlewares/Armink/EasyLogger/easylogger/plugins/flash/: elog_flash.c
    ../Ports/Armink/Easylogger/plugins/flash/: elog_flash_port.c
  group Middlewares/Armink/Easylogger/Port
    ../Ports/Armink/Easylogger/port/: elog_port.c
  group Middlewares/Armink/Easylogger/Src
    ../../../../Middlewares/Armink/EasyLogger/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group Middlewares/Armink/Fal/Port
    ../Ports/Armink/Fal/port/: drv_flash_l4.c
  group Middlewares/Armink/Fal/Src
    ../../../../Middlewares/Armink/Fal/src/: fal.c fal_flash.c fal_partition.c
  group Middlewares/Micrium/uC-CLK/Cfg
    ../Ports/Micrium/uC-CLK/Cfg/: clk_cfg.h
  group Middlewares/Micrium/uC-CLK/Source
    ../../../../Middlewares/Micrium/uC-CLK/Source/: clk.c clk.h
  group Middlewares/Micrium/uC-Common
    ../../../../Middlewares/Micrium/uC-Common/: common_err.h
  group Middlewares/Micrium/uC-Common/Auth
    ../../../../Middlewares/Micrium/uC-Common/Auth/: auth.c auth.h
  group Middlewares/Micrium/uC-Common/Collections
    ../../../../Middlewares/Micrium/uC-Common/Collections/: slist.c slist.h
  group Middlewares/Micrium/uC-CRC/Cfg
    ../Ports/Micrium/uC-CRC/Cfg/: crc_cfg.h
  group Middlewares/Micrium/uC-CRC/Source
    ../../../../Middlewares/Micrium/uC-CRC/Source/: crc_util.c crc_util.h ecc.h ecc_hamming.c ecc_hamming.h edc_crc.c edc_crc.h
  group Middlewares/Micrium/uC-LIB/Config
    ../Ports/Micrium/uC-LIB/Config/: lib_cfg.h
  group Middlewares/Micrium/uC-LIB/Ports
    ../Ports/Micrium/uC-LIB/Ports/: cpu.h
  group Middlewares/Micrium/uC-LIB/Ports/IAR
    ../../../../Middlewares/Micrium/uC-LIB/Ports/IAR/: lib_mem_a.asm
  group Middlewares/Micrium/uC-LIB/Source
    ../../../../Middlewares/Micrium/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Middlewares/Micrium/uC-Shell/Cfg
    ../Ports/Micrium/uC-Shell/Cfg/: shell_cfg.h
  group Middlewares/Micrium/uC-Shell/Cmd/General
    ../../../../Middlewares/Micrium/uC-Shell/Cmd/General/: sh_shell.c sh_shell.h
  group Middlewares/Micrium/uC-Shell/Source
    ../../../../Middlewares/Micrium/uC-Shell/Source/: shell.c shell.h
  group Middlewares/Micrium/uC-Shell/Terminal/Cfg
    ../Ports/Micrium/uC-Shell/Terminal/Cfg/: terminal_cfg.h
  group Middlewares/Micrium/uC-Shell/Terminal/Mode/VT100
    ../../../../Middlewares/Micrium/uC-Shell/Terminal/Mode/VT100/: terminal_mode.c
  group Middlewares/Micrium/uC-Shell/Terminal/Serial
    ../Ports/Micrium/uC-Shell/Terminal/Serial/: terminal_serial.c
  group Middlewares/Micrium/uC-Shell/Terminal/Source
    ../../../../Middlewares/Micrium/uC-Shell/Terminal/Source/: terminal.c terminal.h
  group Middlewares/OSAL/Config
    ../Ports/OSAL/Cfg/: OSAL_Config.h
  group Middlewares/OSAL/Port
    ../Ports/OSAL/Port/: OSAL_Port.c
  group Middlewares/OSAL/Source/Inc
    ../../../../Middlewares/OSAL/Source/Inc/: OSAL.h OSAL_Cbtimer.h OSAL_Clock.h OSAL_Mutex.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h
  group Middlewares/OSAL/Source/Src
    ../../../../Middlewares/OSAL/Source/Src/: OSAL.c OSAL_Cbtimer.c OSAL_Clock.c OSAL_Mutex.c OSAL_PwrMgr.c OSAL_Timers.c
  group Middlewares/SEGGER/HardFault/Source
    ../../../../Middlewares/SEGGER/HardFault/Source/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group Middlewares/SEGGER/SystemView/Config
    ../../../../Middlewares/SEGGER/SystemView/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h
  group Middlewares/SEGGER/SystemView/Sample/NoOS/Config/Cortex-M
    ../../../../Middlewares/SEGGER/SystemView/Sample/NoOS/Config/Cortex-M/: SEGGER_SYSVIEW_Config_NoOS.c
  group Middlewares/SEGGER/SystemView/SEGGER
    ../../../../Middlewares/SEGGER/SystemView/SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_GCC.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_Syscalls_SES.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
  group Module/DataStructure/Inc
    ../../../../Module/DataStructure/Inc/: Array.h Fifo.h LinkList.h List.h Queue.h Ring.h
  group Module/DataStructure/Src
    ../../../../Module/DataStructure/Src/: Array.c Fifo.c LinkList.c List.c Queue.c Ring.c
  group Module/FlexibleButton
    ../../../../Module/FlexibleButton/: flexible_button.c flexible_button.h
  group Module/Printf
    ../../../../Module/Printf/: printf.c printf.h
  group Module/Tlsf/Cfg
    ../Ports/Tlsf/Cfg/: tlsf_malloc_arch.h
  group Module/Tlsf/Port
    ../Ports/Tlsf/Port/: tlsf_malloc_arch.c
  group Module/Tlsf/Source
    ../../../../Module/Tlsf/: tlsf.c tlsf.h
  group Sample
    ../../../../Sample/: OSAL_GenericApp.c
  group Sample/App
    ../../../../Sample/App/: GenericApp.c GenericApp.h
  group Sample/Hal
    ../../../../Sample/Hal/: hal_drivers.c hal_drivers.h
  group Sample/Hal/Target
    ../../../../Sample/Hal/Target/: hal_led.c hal_led.h
