# IAR project STM32F103CBT6.ewp, settings and files
configuration STM32F103CBT6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\..\..\..\Middlewares\SystemView\Config; ..\..\..\..\Middlewares\SystemView\SEGGER; ..\..\..\..\Middlewares\OSAL\App; ..\..\..\..\Middlewares\OSAL\Core\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\Middlewares\SystemView\Config; ..\..\..\..\Middlewares\SystemView\SEGGER
  OBJCOPY.OOCOutputFile: STM32F103CBT6.hex
  ILINK.IlinkOutputFile: STM32F103CBT6.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Middlewares/HardFault/Source
    ../../../../Middlewares/HardFault/Source/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group Middlewares/OSAL/App
    ../../../../Middlewares/OSAL/App/: GenericApp.c GenericApp.h OSAL_GenericApp.c
  group Middlewares/OSAL/Core/Inc
    ../../../../Middlewares/OSAL/Core/Inc/: OSAL.h OSAL_Bufmgr.h OSAL_Cbtimer.h OSAL_Clock.h OSAL_Comdef.h OSAL_Debug.h List.h OSAL_Memory.h OSAL_Nv.h OSAL_Printf.h OSAL_PwrMgr.h Queue.h Ring.h OSAL_Tasks.h OSAL_Timers.h
  group Middlewares/OSAL/Core/Src
    ../../../../Middlewares/OSAL/Core/Src/: OSAL.c OSAL_Bufmgr.c OSAL_Cbtimer.c OSAL_Clock.c List.c OSAL_Memory.c OSAL_Nv.c OSAL_Port.c OSAL_Printf.c OSAL_PwrMgr.c Queue.c Ring.c OSAL_Timers.c
  group Middlewares/SystemView/Config
    ../../../../Middlewares/SystemView/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h
  group Middlewares/SystemView/Sample/NoOS/Config/Cortex-M
    ../../../../Middlewares/SystemView/Sample/NoOS/Config/Cortex-M/: SEGGER_SYSVIEW_Config_NoOS.c
  group Middlewares/SystemView/SEGGER
    ../../../../Middlewares/SystemView/SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_GCC.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_Syscalls_SES.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
